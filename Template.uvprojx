# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\UCOSIII\uC-BSP;.\UCOSIII\uC-CONFIG;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uC-PORT;.\UCOSIII\uC-SOURCE;.\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group APP
    ./APP/led/: led.c
  group UC_BSP
    ./UCOSIII/uC-BSP/: bsp.c
  group UC_CONFIG
    ./UCOSIII/uC-CONFIG/: os_app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
  group UC_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c cpu.h
  group UC_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UC_PORT
    ./UCOSIII/uC-PORT/: os_cpu_c.c os_cpu_a.asm
  group UC_SOURCE
    ./UCOSIII/uC-SOURCE/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
